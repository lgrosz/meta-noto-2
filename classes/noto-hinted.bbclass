PACKAGES = "\
  ${PN}-hinted \
"
